# Keil uVision project 接收端.uvprojx, settings and files
target 接收端 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 接收端 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ADC;..\Common;..\CORE;..\DS1302;..\EEPROM;..\ESP8266;..\FONT;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SPI;..\KEY;..\Memu;..\NRF24L01;..\STM32\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\LED;..\SYSTEM\sys;..\Usart;..\Usart;..\RC522;..\RC522;..\EDP;..\EDP;..\TIM;..\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group EEPROM
    ../EEPROM/: flash.c
  group ESP8266
    ../ESP8266/: esp8266.c
  group HW
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: spi.c
  group STM32
    ../STM32/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group EDP
    ../EDP/: EdpKit.c onenet.c
  group TIM
    ../TIM/: Tim.c
